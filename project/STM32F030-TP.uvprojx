# Keil uVision project STM32F030-TP.uvprojx, settings and files
target STM32TP (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: STM32TP +hex
  c flags: wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\user;..\drive;..\stm32f0;..\lib\STM32F0xx_StdPeriph_Driver\inc;..\lib\STM32F0xx_StdPeriph_Driver\src;..\ht1621;..\;..\epm7064s;..\eeprom;..\rtc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../user/: global.c main.c timer.c uart.c filter.c ad_acquire.c led.c
  group lib
    ../lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_adc.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_exti.c stm32f0xx_i2c.c stm32f0xx_rtc.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_syscfg.c stm32f0xx_dma.c
  group HT1621
    ../HT1621/: ht1621_driver.c key.c ht1621_driver.h key.h
  group epm7064s
    ../epm7064s/: epm7064s.c epm7064s.h
  group eeprom
    ../eeprom/: I2C.h I2C.c
  group rtc
    ../rtc/: Calendar.c rtc.c
  group ::Device
    RTE/Device/STM32F030R8/: startup_stm32f030.s system_stm32f0xx.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.5.0
